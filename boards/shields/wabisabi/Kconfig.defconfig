## boards/shields/wabisabi/Kconfig.defconfig
```kconfig
if SHIELD_WABISABI

config ZMK_KEYBOARD_NAME
    default "WabiSabi"

endif # SHIELD_WABISABI
```
